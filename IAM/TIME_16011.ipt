# Autodesk Inventor part: TIME_16011
## iProperties
Created: 2011-12
Part Number: TIME_16011
Document SubType Name: Modeling
Designer: taborsky
Author: taborsky
## Feature names
1. Base1
