# Autodesk Inventor assembly: TIME_160
## iProperties
Created: 2011-12
Part Number: TIME_160
Document SubType Name: Assembly
Designer: taborsky
Author: taborsky
