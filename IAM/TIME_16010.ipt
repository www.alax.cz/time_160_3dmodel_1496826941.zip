# Autodesk Inventor part: TIME_16010
## iProperties
Created: 2011-12
Part Number: TIME_16010
Document SubType Name: Modeling
Designer: taborsky
Author: taborsky
## Feature names
1. Base1
