# Autodesk Inventor part: TIME_1605
## iProperties
Created: 2011-12
Part Number: TIME_1605
Document SubType Name: Modeling
Designer: taborsky
Author: taborsky
## Feature names
1. Base1
