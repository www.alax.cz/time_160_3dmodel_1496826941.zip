# Autodesk Inventor part: TIME_1604
## iProperties
Created: 2011-12
Part Number: TIME_1604
Document SubType Name: Modeling
Designer: taborsky
Author: taborsky
